Commit message: Backup for controlling Gazebo UR5

File: simulation/ur5_description/ur5_test_gripper.urdf (robot description, URDF)
Before this commit: robot ur5, 19 links, 18 joints
Joints:
- joint world_joint: origin xyz=1.15 1.0 1.0 rpy=0.0 0.0 -1.57 -> xyz=1.5 1.0 1.1 rpy=0.0 0.0 -1.57

Commit message: Start adding gripper to UR5 and create testing samples

File: simulation/ur5_description/ur5.urdf (robot description, URDF)
Before this commit: robot ur5, 10 links, 9 joints
Joints:
- joint world_joint: origin xyz=0.0 0.0 0.0 rpy=0.0 0.0 0.0 -> xyz=1.15 1.0 1.0 rpy=0.0 0.0 -1.57
